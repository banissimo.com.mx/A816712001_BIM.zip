Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: twin_toilet_roll_holder_without_cover.ifc.ifc
Time: 2022-03-22T19:47:53
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - IfcClassification (BO_ifcclas): Furnishing Element
